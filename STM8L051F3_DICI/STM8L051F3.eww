<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STM8L051F3.ewp</path>
    </project>
    <batchBuild />
</workspace>
