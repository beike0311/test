# IAR project STM8L051F3.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L05X_LD_VL
  ICCSTM8.CCIncludePath2: Libraries\STM8L15x_StdPeriph_Driver\inc; ; Device
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8L051F3.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Device
    Device/: delay.c dici.c nb_iot.c uart1.c
  group STM_Std_Lib
    Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_exti.c stm8l15x_gpio.c stm8l15x_syscfg.c stm8l15x_usart.c
  group User_app
    ./: main.c stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
